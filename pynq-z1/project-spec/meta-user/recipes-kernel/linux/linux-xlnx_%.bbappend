SRC_URI += "file://user_2018-08-18-22-54-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

